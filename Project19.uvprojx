# Keil uVision project Project19.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project19
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: LCD_ILI9325

4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c asciiLib.c LCD_ILI9325.c Open1768_LCD.c TP_Open1768.c asciiLib.h LCD_ILI9325.h Open1768_LCD.h TP_Open1768.h notes.h at45db041x.c spi_master.c at45db041x.h spi_master.h
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS:CORE 5.6.0, Board Support:Buttons 1.0.0, Board Support:Joystick 1.0.0, CMSIS Driver:SPI:SPI 2.2.0, CMSIS Driver:USART 2.10.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
